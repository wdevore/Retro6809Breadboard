File: 6809RetroBB/6809RetroBB.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: Minor comments
Other:
- added sheet RAM ROM1 V2 (ram_rom.kicad_sch)
- moved on the sheet: U?
